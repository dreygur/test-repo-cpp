# Keil uVision project W3.uvprojx, settings and files
target W3 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L063R8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: W3 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L063xx
  c include: ../Inc;                   ../Drivers/STM32L0xx_HAL_Driver/Inc;                   ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;                   ../Drivers/CMSIS/Device/ST/STM32L0xx/Include;                   ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32l063xx.s
  group Application/User
    ../Src/: app_main.c cc1101.c common.c modbus_driver.c modbus_app_layer.c gpio.c GW_BRProtocolsImp.c Logger.c radio.c receive_interrupt.c spi.c usart.c watchdog.c power_management.c parameters.c rtc.c external_flash.c State_machine.c eeprom.c bootloader_support.c BIT.c encryption.c main.c stm32l0xx_it.c stm32l0xx_hal_msp.c PC_GW_ProtocolFunctions.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_cryp.c stm32l0xx_hal_cryp_ex.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_rng.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c
  group Drivers/CMSIS
    ..//Src/: system_stm32l0xx.c
software components: CMSIS:CORE 4.3.0
